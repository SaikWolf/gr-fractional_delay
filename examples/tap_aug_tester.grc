<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>D</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>D</value></param>
<param><key>value</key><value>int(len(taps)/2)+1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fd</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fd_taps_v0</value></param>
<param><key>value</key><value>taps_fd_0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fd_taps_v1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>taps_fd_0[int(len(taps)/2)+1:int(len(taps)/2)+len(taps)+1]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>int_tapsA</value></param>
<param><key>value</key><value>firdes.low_pass_2(1,2,.5,.05,80,5)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_0</value></param>
<param><key>value</key><value>max(taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_1</value></param>
<param><key>value</key><value>max(taps_fd)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_tapsA</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(1,2,1,0.35,23)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>[x/sqrt(weight) for x in tapsA]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tapsA</value></param>
<param><key>value</key><value>int_tapsA</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_fd</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>tap_gen.augment_sinc(1,1,.25,fd,2,taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_fd</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>tap_gen.augment_dirichlet(1,1,.25,fd,2,taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_fd</value></param>
<param><key>value</key><value>fd_taps_v0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_fd_0</value></param>
<param><key>value</key><value>tap_gen.augment_lms(1,1,.25,fd,2,taps,2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_fd_len</value></param>
<param><key>value</key><value>len(taps_fd)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_len</value></param>
<param><key>value</key><value>len(taps)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>weight</value></param>
<param><key>value</key><value>sum([x*x for x in tapsA])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>weight_0</value></param>
<param><key>value</key><value>sum([x*x for x in taps])</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>weight_1</value></param>
<param><key>value</key><value>sum([x*x for x in taps_fd])</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>2</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>1000</value></param>
<param><key>type</key><value>int</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>D</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>int</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>[exp(2j*pi*x/2) for x in range(2)]</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>from fractional_delay import tap_gen;from math import sqrt,pi;from cmath import exp</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>interp</key><value>2</value></param>
<param><key>taps</key><value>taps_fd</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
